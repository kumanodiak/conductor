## Kconfig
```kconfig
config CONDUCTOR_FIRMWARE_VERSION
    string "Conductor firmware version"
    default "4.1"
```
